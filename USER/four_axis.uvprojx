# Keil uVision project four_axis.uvprojx, settings and files
target PPM_MOT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PPM_MOT +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\EXTI;..\HARDWARE\BEEP;..\HARDWARE\HEART;..\HARDWARE\RC;..\HARDWARE\BSP_MOTOR_TIM4;..\HARDWARE\CONTROL;..\HARDWARE\STRUCT_ALL;..\HARDWARE\PROTOCOL;..\HARDWARE\IIC_MPU;..\HARDWARE\IIC_MPU\eMPL;..\HARDWARE\HCSR04
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/HEART/: heart.c
    ../HARDWARE/RC/: rc.c
    ../HARDWARE/BSP_MOTOR_TIM4/: bsp_motor_tim4.c
    ../HARDWARE/CONTROL/: control.c
    ../HARDWARE/STRUCT_ALL/: Struct_all.c
    ../HARDWARE/IIC_MPU/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/PROTOCOL/: protocol.c
    ../HARDWARE/IIC_MPU/: iic_mpu6050.c
    ../HARDWARE/HCSR04/: hcsr04.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_tim.c
  group README
    ../: README.TXT
